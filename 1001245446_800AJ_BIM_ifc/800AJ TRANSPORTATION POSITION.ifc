Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-11-03T14:17:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - Alternate UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 03 14:17:09 2020 * Host: CHTSW00356 * Database: C:\Users\174558\AppData\Local\Temp\{17B6E8E8-2AF4-4493-8F34-F6AC14D18F88}\ifc * Database version: 5507 * Database creation date: Tue Nov 03 14:17:04 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 03 14:17:04 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 03 14:17:04 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 ft

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 ft

# IfcTransportElement: Stowed Position, 1001245446_800AJ:Stowed Position:298587
In: Level 1
Type - Material: button r, button g, cover metal(1), button 1, JLG_Metal Paint_White, JLG_Metal Paint_Black, JLG_Paint_Orange, JLG_Paint_Beige, JLG_Rubber_Black, JLG_Plastic_Dark Grey, JLG_Steel, JLG_Paint_Black
OperationType: ELEVATOR; CapacityByWeight: 0 kg; CapacityByNumber: 0
Pset_ManufacturerTypeInformation - ModelReference: JLG - Articulating Boom Lift; Manufacturer: JLG; ProductionYear: n/a
